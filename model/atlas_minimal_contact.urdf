Commit message: feat: add floating joint to urdf

File: model/atlas_minimal_contact.urdf (robot description, URDF)
Before this commit: robot atlas, 60 links, 59 joints
Links:
- added link world
Joints:
- added joint world_joint: type floating, parent world, child pelvis, origin xyz=0 0 0 rpy=0 0 0
